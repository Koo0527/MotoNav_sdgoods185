#pragma once
#include <stdint.h>
#include <string.h>
// 农历：16 个汉字 16x16 单色位图 + 公历->农历换算。由 gen_lunar_font.py 自动生成。
#define LUNAR_GLYPH_W 16
#define LUNAR_GLYPH_H 16

static const uint32_t lunarCp[16] = {0x6B63,0x4E8C,0x4E09,0x56DB,0x4E94,0x516D,0x4E03,0x516B,0x4E5D,0x5341,0x51AC,0x814A,0x95F0,0x521D,0x5EFF,0x6708};

static const uint8_t lunarBmp[16][32] = {
  {0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xFE,0x00,0x80,0x00,0x80,0x00,0x80,0x10,0x80,0x10,0xFC,0x10,0xFC,0x10,0x80,0x10,0x80,0x10,0x80,0x10,0x80,0x7F,0xFE,0x7F,0xFE},
  {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0xFE,0x00,0x00},
  {0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1F,0xF0,0x1F,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7F,0xFE,0x00,0x00},
  {0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xFC,0x66,0x46,0x62,0x46,0x66,0x46,0x66,0x46,0x64,0x46,0x64,0x46,0x6C,0x7C,0x78,0x06,0x60,0x06,0x7F,0xFC,0x7F,0xFC,0x60,0x04},
  {0x00,0x00,0x00,0x00,0x00,0x00,0x3F,0xFC,0x03,0x00,0x03,0x00,0x02,0x00,0x02,0x00,0x1F,0xF0,0x02,0x10,0x02,0x10,0x06,0x10,0x06,0x10,0x04,0x10,0x7F,0xFE,0x7F,0xFE},
  {0x00,0x00,0x00,0x00,0x01,0x00,0x01,0x80,0x00,0x80,0x00,0x00,0x7F,0xFE,0x00,0x00,0x00,0x00,0x04,0x20,0x0C,0x30,0x08,0x18,0x18,0x08,0x30,0x0C,0x20,0x06,0x60,0x02},
  {0x00,0x00,0x00,0x00,0x06,0x00,0x06,0x00,0x06,0x00,0x06,0x00,0x06,0x3E,0x0F,0xF0,0x7E,0x00,0x06,0x00,0x06,0x00,0x06,0x00,0x06,0x06,0x06,0x06,0x02,0x04,0x03,0xFC},
  {0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x60,0x04,0x60,0x04,0x20,0x04,0x20,0x0C,0x20,0x0C,0x20,0x08,0x30,0x08,0x10,0x18,0x18,0x10,0x08,0x30,0x0C,0x60,0x04,0x40,0x02},
  {0x00,0x00,0x00,0x00,0x02,0x00,0x02,0x00,0x02,0x00,0x06,0x00,0x7F,0xF0,0x06,0x30,0x06,0x30,0x04,0x30,0x04,0x30,0x0C,0x30,0x08,0x30,0x18,0x33,0x30,0x33,0x60,0x1E},
  {0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x7F,0xFE,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80},
  {0x00,0x00,0x00,0x00,0x02,0x00,0x07,0xF0,0x0C,0x30,0x1C,0x30,0x32,0x60,0x01,0x80,0x07,0xE0,0x1C,0x3C,0x72,0x0E,0x03,0xC0,0x00,0x60,0x0C,0x00,0x07,0x80,0x00,0xF0},
  {0x00,0x00,0x00,0x00,0x3C,0xC8,0x2C,0xC8,0x25,0xFE,0x24,0xC8,0x3C,0xC8,0x27,0xFE,0x24,0x00,0x24,0xFC,0x3C,0x84,0x24,0x84,0x64,0xFC,0x44,0x84,0x44,0x84,0x5C,0xFC},
  {0x00,0x00,0x00,0x00,0x33,0xFC,0x18,0x06,0x08,0x02,0x60,0x06,0x6F,0xF6,0x61,0x86,0x61,0x86,0x67,0xE6,0x61,0x86,0x60,0x86,0x61,0x86,0x6F,0xF2,0x60,0x06,0x60,0x1E},
  {0x00,0x00,0x00,0x00,0x10,0x00,0x09,0xFE,0x7C,0x66,0x0C,0x46,0x0C,0x46,0x08,0x46,0x1A,0x46,0x3C,0x46,0x7C,0xC6,0x52,0xC4,0x10,0x84,0x11,0x84,0x11,0x04,0x12,0x3C},
  {0x00,0x00,0x00,0x00,0x08,0x10,0x08,0x10,0x08,0x10,0x0C,0x10,0x7F,0xFE,0x08,0x10,0x08,0x10,0x08,0x10,0x08,0x10,0x08,0x10,0x08,0x10,0x08,0x10,0x0F,0xF0,0x08,0x10},
  {0x00,0x00,0x00,0x00,0x0F,0xF8,0x1F,0xF8,0x18,0x08,0x18,0x08,0x1F,0xF8,0x1F,0xF8,0x18,0x08,0x10,0x08,0x1F,0xF8,0x10,0x08,0x10,0x08,0x30,0x08,0x60,0x08,0x40,0x78},
};

static const uint32_t LUNAR_INFO[201] = {
  0x4BD8,0x4AE0,0xA570,0x54D5,0xD260,
  0xD950,0x16554,0x56A0,0x9AD0,0x55D2,
  0x4AE0,0xA5B6,0xA4D0,0xD250,0x1D255,
  0xB540,0xD6A0,0xADA2,0x95B0,0x14977,
  0x4970,0xA4B0,0xB4B5,0x6A50,0x6D40,
  0x1AB54,0x2B60,0x9570,0x52F2,0x4970,
  0x6566,0xD4A0,0xEA50,0x6E95,0x5AD0,
  0x2B60,0x186E3,0x92E0,0x1C8D7,0xC950,
  0xD4A0,0x1D8A6,0xB550,0x56A0,0x1A5B4,
  0x25D0,0x92D0,0xD2B2,0xA950,0xB557,
  0x6CA0,0xB550,0x15355,0x4DA0,0xA5B0,
  0x14573,0x52B0,0xA9A8,0xE950,0x6AA0,
  0xAEA6,0xAB50,0x4B60,0xAAE4,0xA570,
  0x5260,0xF263,0xD950,0x5B57,0x56A0,
  0x96D0,0x4DD5,0x4AD0,0xA4D0,0xD4D4,
  0xD250,0xD558,0xB540,0xB6A0,0x195A6,
  0x95B0,0x49B0,0xA974,0xA4B0,0xB27A,
  0x6A50,0x6D40,0xAF46,0xAB60,0x9570,
  0x4AF5,0x4970,0x64B0,0x74A3,0xEA50,
  0x6B58,0x55C0,0xAB60,0x96D5,0x92E0,
  0xC960,0xD954,0xD4A0,0xDA50,0x7552,
  0x56A0,0xABB7,0x25D0,0x92D0,0xCAB5,
  0xA950,0xB4A0,0xBAA4,0xAD50,0x55D9,
  0x4BA0,0xA5B0,0x15176,0x52B0,0xA930,
  0x7954,0x6AA0,0xAD50,0x5B52,0x4B60,
  0xA6E6,0xA4E0,0xD260,0xEA65,0xD530,
  0x5AA0,0x76A3,0x96D0,0x4AFB,0x4AD0,
  0xA4D0,0x1D0B6,0xD250,0xD520,0xDD45,
  0xB5A0,0x56D0,0x55B2,0x49B0,0xA577,
  0xA4B0,0xAA50,0x1B255,0x6D20,0xADA0,
  0x14B63,0x9370,0x49F8,0x4970,0x64B0,
  0x168A6,0xEA50,0x6B20,0x1A6C4,0xAAE0,
  0xA2E0,0xD2E3,0xC960,0xD557,0xD4A0,
  0xDA50,0x5D55,0x56A0,0xA6D0,0x55D4,
  0x52D0,0xA9B8,0xA950,0xB4A0,0xB6A6,
  0xAD50,0x55A0,0xABA4,0xA5B0,0x52B0,
  0xB273,0x6930,0x7337,0x6AA0,0xAD50,
  0x14B55,0x4B60,0xA570,0x54E4,0xD160,
  0xE968,0xD520,0xDAA0,0x16AA6,0x56D0,
  0x4AE0,0xA9D4,0xA2D0,0xD150,0xF252,
  0xD520,
};

static int lYearDays(int y){
  int info=LUNAR_INFO[y-1900],s=348,i=0x8000;
  for(;i>0x8;i>>=1) if(info&i) s++;
  if(info&0xf) s += (info&0x10000)?30:29;
  return s;
}
static int leapMonth(int y){ return LUNAR_INFO[y-1900]&0xf; }
static int leapDays(int y){ int lm=leapMonth(y); if(!lm) return 0; return (LUNAR_INFO[y-1900]&0x10000)?30:29; }
static int monthDays(int y,int m){ return (LUNAR_INFO[y-1900]&(0x10000>>m))?30:29; }

static void solar2lunar(int y,int m,int d,int &ly,int &lm,int &ld,bool &isLeap){
  static const int md[]={31,28,31,30,31,30,31,31,30,31,30,31};
  auto days=[&](int yy,int mm,int dd){
    int s=0; for(int i=1900;i<yy;++i) s+=(i%4==0&&(i%100!=0||i%400==0))?366:365;
    for(int i=1;i<mm;++i) s+=md[i-1]+(i==2&&(yy%4==0&&(yy%100!=0||yy%400==0))?1:0);
    return s+dd-1;
  };
  int offset=days(y,m,d)-days(1900,1,31);
  int i=1900,temp=0; isLeap=false;
  for(; i<2101 && offset>0; ++i){ temp=lYearDays(i); offset-=temp; }
  if(offset<0){ offset+=temp; --i; }
  ly=i; int leap=leapMonth(ly); i=1;
  for(; i<13 && offset>0; ++i){
    if(leap>0 && i==(leap+1) && !isLeap){ --i; isLeap=true; temp=leapDays(ly); }
    else { temp=monthDays(ly,i); }
    if(isLeap && i==(leap+1)) isLeap=false;
    offset-=temp;
  }
  if(offset==0 && leap>0 && i==leap+1){ if(isLeap) isLeap=false; else { isLeap=true; --i; } }
  if(offset<0){ offset+=temp; --i; }
  lm=i; ld=offset+1;
}

// 农历格式化：闰X月 + 日（初/十/廿）。out 至少 24 字节。
static void formatLunar(int m,bool leap,int d,char *out){
  static const char* mn[12]={"æ­£","äº","ä¸","å","äº","å­","ä¸","å«","ä¹","å","å¬","è"};
  static const char* ones[10]={"ä¸","äº","ä¸","å","äº","å­","ä¸","å«","ä¹","å"};
  static const char yue[4]="\xE6\x9C\x88";
  int o=0;
  if(leap){ memcpy(out+o,"\xE9\x98\x8D",3); o+=3; }
  memcpy(out+o,mn[m-1],3); o+=3;
  memcpy(out+o,yue,3); o+=3;
  if(d<=10){ memcpy(out+o,"\xE5\x88\x9D",3); memcpy(out+o+3,ones[d-1],3); o+=6; }
  else if(d<20){ memcpy(out+o,"\xE5\x8D\x81",3); memcpy(out+o+3,ones[d-11],3); o+=6; }
  else if(d==20){ memcpy(out+o,"\xE4\xBA\x8C\xE5\x8D\x81",6); o+=6; }
  else if(d<30){ memcpy(out+o,"\xE5\xBB\xBF",3); memcpy(out+o+3,ones[d-21],3); o+=6; }
  else { memcpy(out+o,"\xE4\xB8\x89\xE5\x8D\x81",6); o+=6; }
  out[o]=0;
}

static void drawLunarGlyph(uint32_t cp,int x,int y,uint16_t c){
  int idx=-1; for(int i=0;i<16;++i) if(lunarCp[i]==cp){idx=i;break;}
  if(idx<0) return;
  const uint8_t* b=lunarBmp[idx];
  for(int r=0;r<16;++r){
    uint8_t row=b[r]; for(int cc=0;cc<8;++cc) if(row&(0x80>>cc)) gfx->drawPixel(x+cc,y+r,c);
    uint8_t row2=b[16+r]; for(int cc=0;cc<8;++cc) if(row2&(0x80>>cc)) gfx->drawPixel(x+8+cc,y+r,c);
  }
}

// 绘制 UTF-8 农历串；每个汉字 16x16，逐字右移。x,y 为左上角。
static void drawLunar(const char* s,int x,int y,uint16_t c){
  while(*s){
    uint32_t cp=0; int n=0;
    if(!(*s&0x80)){ cp=*s++; n=1; }
    else if((*s&0xE0)==0xC0){ cp=((s[0]&0x1F)<<6)|(s[1]&0x3F); s+=2; n=2; }
    else if((*s&0xF0)==0xE0){ cp=((s[0]&0x0F)<<12)|((s[1]&0x3F)<<6)|(s[2]&0x3F); s+=3; n=3; }
    else { s++; continue; }
    if(n==0) break;
    drawLunarGlyph(cp,x,y,c); x+=16;
  }
}
